# Keil uVision project 12.uvprojx, settings and files
target Target 1 (6210000::V6.21::ARMCLANG)
  device: STM32L496ZGTx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00040000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: 12
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: HD44780.c HD44780.h main.c Myfun.c Myfun.h
software components: CMSIS:CORE 5.6.0, Device:Startup 1.3.2
